# Keil uVision project APP_LAYER_.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: testfinalisa +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\TM4C123GH6PM\Common;D:\TM4C123GH6PM\MCAL\01_GPIO;D:\TM4C123GH6PM\MCAL\03_SYSTICK;D:\TM4C123GH6PM\MCAL\04_PWM;D:\TM4C123GH6PM\MCAL\02-NVIC
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group gpio
    D:/TM4C123GH6PM/MCAL/01_GPIO/: app.c clk.c dio.c
  group app
    D:/TM4C123GH6PM/MCAL/01_GPIO/: main.c
  group systick
    D:/TM4C123GH6PM/MCAL/03_SYSTICK/: timer_program.c
  group NVIC
    D:/TM4C123GH6PM/MCAL/02-NVIC/: nvic_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
